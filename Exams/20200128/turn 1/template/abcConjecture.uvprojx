# Keil uVision project abcConjecture.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.1
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: abcConjecture
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group ADC_DAC
    ./ADC_DAC/: IRQ_adc.c lib_adc_dac.c
  group button
    ./button/: IRQ_button.c lib_button.c
  group led
    ./led/: lib_led.c
  group timer
    ./timer/: IRQ_timer.c lib_timer.c
  group main
    ./: sample.c
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.0

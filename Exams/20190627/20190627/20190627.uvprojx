# Keil uVision project 20190627.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.1
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 20190627
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group main
    ./: main.c
  group button
    ./button/: IRQ_button.c lib_button.c
  group led
    ./led/: lib_led.c
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.0
